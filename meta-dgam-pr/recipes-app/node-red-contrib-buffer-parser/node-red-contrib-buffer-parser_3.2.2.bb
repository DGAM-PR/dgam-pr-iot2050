PR = "1"

inherit npm
inherit node-red-module

DESCRIPTION = "A Node-RED node to easily convert values in buffers/arrays to/from many data types"
