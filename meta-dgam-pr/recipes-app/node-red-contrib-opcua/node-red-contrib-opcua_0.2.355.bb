PR = "1"

inherit npm
inherit node-red-module

DESCRIPTION = "OPC UA nodes for Node-RED (node-opcua based)"
